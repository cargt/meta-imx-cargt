CARGT_SWU_IMAGE = "cargt-image-dev"

require cargt-image-swu.inc
