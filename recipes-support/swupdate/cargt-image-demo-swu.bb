CARGT_SWU_IMAGE = "cargt-image-demo"

require cargt-image-swu.inc
