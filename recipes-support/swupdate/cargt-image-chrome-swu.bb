CARGT_SWU_IMAGE = "cargt-image-chrome"

require cargt-image-swu.inc
