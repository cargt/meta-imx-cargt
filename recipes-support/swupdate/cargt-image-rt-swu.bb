CARGT_SWU_IMAGE = "cargt-image-rt"

require cargt-image-swu.inc

# rt is only built for these machines
COMPATIBLE_MACHINE = "(imx95-cargt-00414-.*|imx95-15x15-lpddr4x-frdm)"
