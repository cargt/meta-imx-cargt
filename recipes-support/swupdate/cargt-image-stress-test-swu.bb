CARGT_SWU_IMAGE = "cargt-image-stress-test"

require cargt-image-swu.inc
