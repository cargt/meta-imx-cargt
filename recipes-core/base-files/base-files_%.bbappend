FILESEXTRAPATHS:prepend:imx93-cargt-00363-00428 := "${THISDIR}/${BPN}:"
FILESEXTRAPATHS:prepend:imx95-cargt-00414-00428 := "${THISDIR}/${BPN}:"
